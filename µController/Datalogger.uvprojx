# Keil uVision project Datalogger.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: LM4F232H5QD Texas Instruments
  pack: Keil.LM4F_DFP.1.0.0
  cpu: IRAM(0x10000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Datalogger
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PGE TARGET_IS_TM4C123_RA1 ENABLE_LFN
  c include: .\Libraries
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  scatter file: .\Datalogger.sct
  link misc: --entry Reset_Handler
  group Source Group 1
    ./: datalogger.c
    ./Libraries/fatfs/port/: mmc-ek-lm4f232.c
    ./Libraries/fatfs/src/: ff.c
    ./Libraries/fatfs/src/option/: cc932.c
    ./Libraries/utils/: uartstdio.c
    ./Libraries/drivers/: cfal96x64x16.c
  group Library
    ./Libraries/: driverlib.lib grlib.lib
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0
